# Keil uVision project 多媒体播放器程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 多媒体播放器程序
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: frag_1.c frag_2.c frag_3.c frag_4.c frag_5.c frag_6.c main.c music_player.c
